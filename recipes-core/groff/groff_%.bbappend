require conf/distro/include/security_flags.inc
CFLAGS:append = " -fPIE"

