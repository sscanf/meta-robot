PACKAGECONFIG:remove = " gl"

