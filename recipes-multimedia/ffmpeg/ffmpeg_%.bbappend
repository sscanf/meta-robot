FILES_${PN}-dev = "/usr/lib/* /usr/include/*"
